# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Users\zghlin\Desktop\kaifa\动态数码管显示2
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Nexie.c
